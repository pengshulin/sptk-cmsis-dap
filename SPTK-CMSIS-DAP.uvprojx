# Keil uVision project SPTK-CMSIS-DAP.uvprojx, settings and files
target SPTK-CMSIS-DAP (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPTK-CMSIS-DAP +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output bin\SPTK-CMSIS-DAP.bin build\SPTK-CMSIS-DAP.axf
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: .;.\USBStack\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group Configuration
    ./: DAP_config.h usb_config.c
  group USB HW Driver
    ./: usbd_STM32F103.c
  group Source
    ./: USBD_Demo.c usbd_user_hid.c
    ./ARM_DAP/: DAP.c JTAG_DP.c SW_DP.c
  group Library
    ./: USB_CM3.lib
